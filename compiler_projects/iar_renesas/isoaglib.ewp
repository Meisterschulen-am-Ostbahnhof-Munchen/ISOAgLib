# IAR project isoaglib.ewp, settings and files
configuration Debug (M32C, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlm32cff.h
  General.GHeapSize: 1024
  General.GStackSize: 256
  General.GIStackSize: 64
  General.Derivative: 90
  General.GFarHeapSize: 1024
  General.GHugeHeapSize: 1024
  ICCM32C.CCDefines: HAL_SUBDIR=pc; SYSTEM_PC=1; USE_ISO_TERMINAL=1
  ICCM32C.CCDiagSuppress: Pe815,Pa050
  ICCM32C.newCCIncludePaths: ..\..\xgpl_src\
  ICCM32C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm32c.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M32C)
  as the first configuration, except:
  General.Derivative: 92
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../xgpl_src/IsoAgLib/comm/SystemMgmt/impl/: baseitem_c.cpp identitem_c.cpp istate_c.cpp
    ../../xgpl_src/IsoAgLib/util/impl/: cancustomer_c.cpp canpkg_c.cpp canpkgext_c.cpp elementbase_c.cpp schedulerentry_c.cpp util_funcs.cpp
    ../../xgpl_src/IsoAgLib/driver/can/impl/: canio_c.cpp filterbox_c.cpp ident_c.cpp
    ../../xgpl_src/IsoAgLib/comm/Multipacket/impl/: chunk_c.cpp multireceive_c.cpp multisend_c.cpp multisendpkg_c.cpp stream_c.cpp streamchunk_c.cpp streamlinear_c.cpp
    ../../xgpl_src/IsoAgLib/driver/eeprom/impl/: eepromio_c.cpp
    ../../xgpl_src/IsoAgLib/util/: iliberr_c.cpp
    ../../xgpl_src/IsoAgLib/comm/SystemMgmt/ISO11783/impl/: isofilterbox_c.cpp isofiltermanager_c.cpp isoitem_c.cpp isomonitor_c.cpp isoname_c.cpp isorequestpgn_c.cpp isosystempkg_c.cpp
    ../../xgpl_src/IsoAgLib/comm/ISO_Terminal/impl/: isoterminal_c.cpp isoterminalpkg_c.cpp vtclientservercommunication_c.cpp vtobject_c.cpp vtobjectalarmmask_c.cpp vtobjectarchedbargraph_c.cpp vtobjectauxiliaryfunction_c.cpp vtobjectauxiliaryinput_c.cpp vtobjectbutton_c.cpp vtobjectcontainer_c.cpp vtobjectdatamask_c.cpp vtobjectellipse_c.cpp vtobjectfillattributes_c.cpp vtobjectfontattributes_c.cpp vtobjectgraphicscontext_c.cpp vtobjectinputattributes_c.cpp vtobjectinputboolean_c.cpp vtobjectinputlist_c.cpp vtobjectinputnumber_c.cpp vtobjectinputstring_c.cpp vtobjectkey_c.cpp vtobjectline_c.cpp vtobjectlinearbargraph_c.cpp vtobjectlineattributes_c.cpp vtobjectmacro_c.cpp vtobjectmeter_c.cpp vtobjectnumbervariable_c.cpp vtobjectobjectpointer_c.cpp vtobjectoutputlist_c.cpp vtobjectoutputnumber_c.cpp vtobjectoutputstring_c.cpp vtobjectpicturegraphic_c.cpp vtobjectpolygon_c.cpp vtobjectrectangle_c.cpp vtobjectsoftkeymask_c.cpp vtobjectstring_c.cpp vtobjectstringvariable_c.cpp vtobjectworkingset_c.cpp vtserverinstance_c.cpp
    ../../xgpl_src/IsoAgLib/comm/ISO_Terminal/: ivtobject_c.cpp
    ../../xgpl_src/IsoAgLib/comm/Scheduler/impl/: scheduler_c.cpp
    ../../xgpl_src/IsoAgLib/driver/system/impl/: system_c.cpp
    ../../xgpl_src/supplementary_driver/driver/datastreams/: volatilememory_c.cpp
